# Keil uVision project keilprj.uvproj, settings and files
target CC2430-TinyOS (MCS-51)
  device: CC2430-F128 Chipcon
  cpu: IRAM(0-0xFE) XRAM(0x0001-0x1EFF) IROM(0-0xFFFF) CLOCK(32000000) MODC2
  output: app
  c flags: Optimize=8 SizeSpeed=1
  group Source Group
    ./: STARTUP.A51 app.c
